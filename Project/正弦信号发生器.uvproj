# Keil uVision project 正弦信号发生器.uvproj, settings and files
target 正弦信号发生器 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 正弦信号发生器 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\DeviceSupport\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\User;..\CMSIS\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_it.c Key_4_4.c Delay.c Wave.c SPFD5408.c SPI.c PeripheralInit.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_fsmc.c
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../User/: system_stm32f10x.c
  group Statup
    ../CMSIS/DeviceSupport/STM32F10x/: startup_stm32f10x_hd.s
